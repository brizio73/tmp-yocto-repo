# Required to make it compile
PACKAGECONFIG_append = " accessibility "
