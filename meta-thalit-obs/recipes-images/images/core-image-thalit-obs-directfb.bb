
require core-thalit-obs.inc

inherit core-image

IMAGE_INSTALL += "packagegroup-core-directfb"


