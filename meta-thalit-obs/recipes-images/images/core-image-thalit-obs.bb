require core-thalit-obs.inc

inherit core-image

SDKIMAGE_FEATURES ?= "dev-pkgs"

