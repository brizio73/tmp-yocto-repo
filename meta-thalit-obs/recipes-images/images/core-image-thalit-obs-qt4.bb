require core-thalit-obs.inc

inherit core-image

IMAGE_INSTALL += "packagegroup-core-qt4e"
#IMAGE_INSTALL += "qt4-embedded"



IMAGE_FEATURES += "splash"