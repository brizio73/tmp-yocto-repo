
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://vct6210-r.cfg"
